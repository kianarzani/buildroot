## package/ecal/Config.in
```kconfig
config BR2_PACKAGE_ECAL
	tristate "ECAL"
	select BR2_PACKAGE_PROTOBUF
	select BR2_PACKAGE_OPENSSL
	help
	  eCAL library for IPC communication
```
